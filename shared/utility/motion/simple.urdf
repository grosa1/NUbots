Commit message: Add some logs

File: shared/utility/motion/simple.urdf (robot description, URDF)
Before this commit: robot compass_gait, 9 links, 8 joints
Links:
- removed link ground
Joints:
- removed joint ground_rotation
- joint floating_base_x: parent ground -> world
